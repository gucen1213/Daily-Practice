# Keil uVision project example.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: example
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _RTE_
  c include: ..\example;.\event;.\mail;.\print_string;.\check_string;.\print_pool;.\3rd-party\PLOOC;..\example
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./: main.c app_cfg.h compiler.h ooc.h simple_fsm.h
  group app_platform
    ./: app_platform.c app_platform.h stdout_USART.c stdout_USART.h LED.c LED.h
  group event
    ./event/: event.c event.h
  group mail
    ./mail/: mail.c mail.h
  group pritn_string
    ./print_string/: print_string.c print_string.h
  group check_string
    ./check_string/: check_string.c check_string.h
  group print_pool
    ./print_pool/: print_pool.c print_pool.h
software components: CMSIS:CORE 5.1.2, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, CMSIS Driver:USART 2.10, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:UART 1.7.4, Device:STM32Cube HAL:USART 1.7.4, Device:Startup 2.6.2
